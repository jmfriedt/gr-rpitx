options:
  parameters:
    generate_options: no_gui
    id: rpi_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48000*5
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    comment: 'Carson: 2*(48+75)=246 kHz'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Radar Love.wav
    repeat: 'True'
  states: {}
- name: rpitx_rpitx_source_0
  id: rpitx_rpitx_source
  parameters:
    carrier_freq: 86.6e6
    samp_rate: samp_rate
  states: {}

connections:
- [analog_wfm_tx_0, '0', rpitx_rpitx_source_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
