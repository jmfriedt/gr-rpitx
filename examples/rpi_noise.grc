options:
  parameters:
    generate_options: no_gui
    id: rpi_noise
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    value: 86.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import socket
      import string
      import sys

      def jmf_server(tt):
      	while True:
      		sock=socket.socket(socket.AF_INET,socket.SOCK_STREAM)
      		sock.setsockopt(socket.SOL_SOCKET,socket.SO_REUSEADDR,1)
      		sock.bind(('192.168.1.168',4242))
      		print("Waiting for connection")
      		sock.listen(1)
      		conn,addr=sock.accept()
      		with conn:
      			print("connected from: ",addr)
      			while True:
      				data=conn.recv(1)
      				if data:
      					data=data.decode()
      					print(data)
      					if '+' in data:
      						tt.f=tt.f+1e4
      					if '-' in data:
      						tt.f=tt.f-1e4
      					tt.set_f(tt.f)
      					if 'q' in data:
      						sock.shutdown(socket.SHUT_RDWR)
      						sock.close()
      						break
  states: {}
- name: rpitx_rpitx_sink_0
  id: rpitx_rpitx_sink
  parameters:
    carrier_freq: f
    samp_rate: samp_rate
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server")
      import threading
      threading.Thread(target=epy_module_0.jmf_server,args=(self,)).start()
    priority: ''
    section: main_after_init
  states: {}

connections:
- [analog_noise_source_x_0, '0', rpitx_rpitx_sink_0, '0']

metadata:
  file_format: 1
