options:
  parameters:
    generate_options: qt_gui
    id: tmp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48000*24
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate/12
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/24
    decim: '12'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/64
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 86.6e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10/4
    fc: '0'
    fftsize: 1024*8
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/10/4
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
